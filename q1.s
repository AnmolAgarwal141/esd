    AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=ELE
	LDR R1,[R0]
	MOV R2,#10;COUNTER
	LDR R3,=ARRAY
	MOV R4,#-1
	LDR R9,=RESULT
	LDR R6,[R3]
UP	CMP R1,R6
	BEQ EQUAL
	LDR R6,[R3,#4]!
	SUB R2,#1
	TEQ R2,#0
	BNE UP
	STR R4,[R9]
STOP B STOP
EQUAL STR R6,[R9]
STOPP B STOPP
ARRAY DCD 0x03,0x0A,0x32,0x12,0x02,0x04,0x07,0xBA,0XB1,0X0C
ELE DCD 0X02
	AREA mydata,DATA,READWRITE
RESULT DCD 0