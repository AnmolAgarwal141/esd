	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=FACT
	LDR R1,=NUM
	LDR R2,[R1]
	BL FACTO
	STR R3,[R0]
STOP B STOP
NUM DCD 0X05
FACTO
	CMP R2,#1
	BEQ EXIT
	PUSH {R2}
	SUB R2,#1
	PUSH {LR}
	BL FACTO
    POP {LR}
	POP {R2}
	MUL R3,R3,R2
	BX LR
EXIT
	MOV R3,#1
	BX LR
	AREA MYDATA1,DATA
FACT DCD 0
	END
	

	
	
	