	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA Code_pg,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=A
	LDR R1,=C
	LDR R5,=Result
	LDR R2,[R0]
	LDR R3,[R1]
	
	TEQ R2,R3
	BEQ Jump
Loop
	CMP R2,R3
	SUBHI R2,R3
	SUBLO R3,R2
	TEQ R2,R3
	BNE Loop
Jump 
	STR R2,[R5]
STOP B STOP
A DCD 0X00000002
C DCD 0X00000004
	AREA Data_pg,DATA,READWRITE
Result DCD 0