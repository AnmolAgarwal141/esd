	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA Code_pg,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	
	LDR R0,=ARR
	LDR R1,=NUM
	LDR R2,=RES
	;MOV R3,R0
	MOV R4,#1
	LDR R5,[R1]
Loop
	LDR R3,[R0],#4
	CMP R5,R3
	BEQ Jump
	ADD R4,#1
	TEQ R4,#10
	BNE Loop
	STOP B STOP
Jump
	STR R4,[R2]
STOP2 B STOP2
ARR DCD 0X010,0X020,0X030,0X040,0X050,0X060,0X070,0X080,0X090,0X0100
NUM DCD 0X040
	AREA Data_pg,DATA,READWRITE
RES DCD 0